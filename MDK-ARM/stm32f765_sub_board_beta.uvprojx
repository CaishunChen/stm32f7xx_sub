# Keil uVision project stm32f765_sub_board_beta.uvprojx, settings and files
target stm32f765_sub_board_beta (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F765BITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: stm32f765_sub_board_beta
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F765xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../Drivers/CMSIS/Include;../User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: usart.c stm32f7xx_hal_msp.c quadspi.c gpio.c fmc.c tim.c stm32f7xx_it.c spi.c main.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_cortex.c stm32f7xx_ll_fmc.c stm32f7xx_hal_spi.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_uart.c stm32f7xx_hal_i2c.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_dma.c stm32f7xx_hal_flash.c stm32f7xx_hal.c stm32f7xx_hal_qspi.c stm32f7xx_hal_gpio.c stm32f7xx_hal_sdram.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_pwr.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Application/MDK-ARM
    ./: startup_stm32f765xx.s
  group API/BSP
    ../User/: bsp_qspi_n25q.c sdram.c spi_handle.c uart.c
software components: CMSIS:CORE 4.1.0
